# Repository waicool20/LaserSwitch

File README.md:

# Laser Switch

Simple learning tool for understanding data transmission using light!

## Project Structure

- `3D`: Contains 3D CAD files
- `Graphics` Contains images
- `Hardware`: Contains PCB schematics and STM32CubeMX IOC file
- `Software`: Software for the MCU

# License

Hardware and 3D: Creative Commons Attribution-ShareAlike 4.0 International

Software: MIT

## KiCad design Hardware/LaserSwitch-Slave/LaserSwitch-Slave.kicad_pcb

Parts:
C1, C3, C4, C5: 22u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2, C17: 6p; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C6, C7, C8, C12, C13, C14, C15, C16: 0.1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C9, C10: 22p; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C11: 2.2u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: SGPIN82MQ-G; JST_XH_S2B-XH-A-1_1x02_P2.50mm_Horizontal
D2: MM3Z3V3T1G; D_SOD-323_HandSoldering
H1, H2, H3: MountingHole_Pad; MountingHole_3.2mm_M3_Pad
J1, J4: Bus; JST_XH_S4B-XH-A-1_1x04_P2.50mm_Horizontal
J2: SWD; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J3: Laser; JST_XH_S3B-XH-A-1_1x03_P2.50mm_Horizontal
R1, R5: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2, R3, R4: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R6: 330; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R7: 15k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
RV1: 50k; 3362P
SW1: Reset; SW_SPST_PTS645
SW2: SW_DIP_x04; SW_DIP_SPSTx04_Slide_6.7x11.72mm_W8.61mm_P2.54mm_LowProfile
TP1: A; TestPoint_Loop_D3.50mm_Drill1.4mm_Beaded
TP2: D; TestPoint_Loop_D3.50mm_Drill1.4mm_Beaded
U1: AMS1117-5.0; SOT-223-3_TabPin2
U2: MCP6022; TSSOP-8_4.4x3mm_P0.65mm
U3: AMS1117-3.3; SOT-223-3_TabPin2
U4: 74LV14; TSSOP-14_4.4x5mm_P0.65mm
U5: DX-BT24
U6: STM32F401RCTx; LQFP-64_10x10mm_P0.5mm
Y1: 8MHz; Crystal_HC49-4H_Vertical

Connections:
+3V3: C5.1, C6.2, C7.1, C12.1, C13.1, C14.1, C15.1, R2.1, R5.2, U3.2 (VO), U4.14 (3.3V), U5.12, U6.13 (VREF+), U6.19 (VDD), U6.32 (VDD), U6.48 (VDD), U6.64 (VDD)
+5V: C3.1, C4.1, C16.1, J2.1, R7.1, U1.2 (VO), U2.8 (V+), U3.3 (VI)
+7.5V: C1.1, J1.4, J3.3, J4.1, U1.3 (VI)
ADC: D2.1 (K), R1.1, U6.25 (PC5)
BT_CONN: U5.17, U6.36 (PB15)
BT_RX: U5.1, U6.38 (PC7)
BT_TX: U5.2, U6.37 (PC6)
GND: C1.2, C3.2, C4.2, C5.2, C6.1, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, D1.2 (A), D2.2 (A), H1.1, H2.1, H3.1, J1.1, J2.4, J3.2, J4.4, R4.2, R6.2, SW1.2, U1.1 (GND), U2.4 (V-), U3.1 (GND), U4.7 (GND), U5.13, U5.14, U5.26, U6.12 (VSSA), U6.18 (VSS), U6.31 (VSS), U6.47 (VSS), U6.63 (VSS)
NRST: C8.1, R2.2, SW1.1, U6.7 (NRST)
unnamed: C2.1, D1.1 (K), R3.2, U2.2 (-)
unnamed: C2.2, R3.1, U2.1, U2.5 (+)
unnamed: C9.1, U6.5 (PH0), Y1.1
unnamed: C10.1, U6.6 (PH1), Y1.2
unnamed: C11.1, U6.30 (VCAP1)
unnamed: C17.1, R6.1, R7.2, U2.3 (+)
unnamed: R1.2, RV1.1, TP1.1, U2.7, U4.1
unnamed: R4.1, RV1.2, U2.6 (-)
unnamed: R5.1, SW2.1, SW2.2, SW2.3, SW2.4
unnamed: SW2.5, U6.11 (PC3)
unnamed: SW2.6, U6.10 (PC2)
unnamed: SW2.7, U6.9 (PC1)
unnamed: SW2.8, U6.8 (PC0)
unnamed: U4.2, U4.3
RX: TP2.1, U4.4, U6.43 (PA10)
SCL: J1.2, J4.3, U6.58 (PB6)
SDA: J1.3, J4.2, U6.59 (PB7)
SWDCLK: J2.2, U6.49 (PA14)
SWDIO: J2.3, U6.46 (PA13)
TX: J3.1, U6.42 (PA9)

Board: 2 copper layers, 93.0 x 30.0 mm, 45 parts (16 on the bottom side), 29 nets.

## KiCad design Hardware/LaserSwitch-Master/LaserSwitch-Master.kicad_pcb

Parts:
C1, C2, C3, C4: 22u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C5, C9, C10, C11, C12, C13: 0.1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C6, C7: 22p; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C8: 2.2u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
J1, J3: Bus; JST_XH_S4B-XH-A-1_1x04_P2.50mm_Horizontal
J2: SWD; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J7: PWR; JST_XH_S2B-XH-A-1_1x02_P2.50mm_Horizontal
R1: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R11, R12: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW1: Reset; SW_SPST_PTS645
TP1: GND; TestPoint_Loop_D3.50mm_Drill0.9mm_Beaded
U1: AMS1117-5.0; SOT-223-3_TabPin2
U2: AMS1117-3.3; SOT-223-3_TabPin2
U3: DX-BT24
U4: STM32F401RCTx; LQFP-64_10x10mm_P0.5mm
Y1: 8MHz; Crystal_HC49-4H_Vertical

Connections:
+3V3: C4.1, C5.2, C9.1, C10.1, C11.1, C13.1, R1.1, R11.2, R12.1, U2.2 (VO), U3.12, U4.13 (VREF+), U4.19 (VDD), U4.32 (VDD), U4.48 (VDD), U4.64 (VDD)
+5V: C2.1, C3.1, J2.1, U1.2 (VO), U2.3 (VI); also elsewhere on the board
+7.5V: C1.1, J1.4, J3.1, J7.2, U1.3 (VI)
BT_CONN: U3.17, U4.36 (PB15)
BT_RX: U3.1, U4.38 (PC7)
BT_TX: U3.2, U4.37 (PC6)
DIR1: U4.25 (PC5); also elsewhere on the board
DIR2: U4.28 (PB2); also elsewhere on the board
DIR3: U4.34 (PB13); also elsewhere on the board
EN1: U4.26 (PB0); also elsewhere on the board
EN2: U4.29 (PB10); also elsewhere on the board
EN3: U4.35 (PB14); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.1, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, J1.1, J2.4, J3.4, J7.1, SW1.2, TP1.1, U1.1 (GND), U2.1 (GND), U3.13, U3.14, U3.26, U4.12 (VSSA), U4.18 (VSS), U4.31 (VSS), U4.47 (VSS), U4.63 (VSS); also elsewhere on the board
NRST: C12.1, R1.2, SW1.1, U4.7 (NRST)
unnamed: C6.1, U4.5 (PH0), Y1.1
unnamed: C7.1, U4.6 (PH1), Y1.2
unnamed: C8.1, U4.30 (VCAP1)
SCL: J1.2, J3.3, R12.2, U4.58 (PB6)
SDA: J1.3, J3.2, R11.1, U4.59 (PB7)
STEP1: U4.24 (PC4); also elsewhere on the board
STEP2: U4.27 (PB1); also elsewhere on the board
STEP3: U4.33 (PB12); also elsewhere on the board
SWDCLK: J2.2, U4.49 (PA14)
SWDIO: J2.3, U4.46 (PA13)

Parts:
J4: Motor; PhoenixContact_MC_1,5_6-G-3.5_1x06_P3.50mm_Horizontal
Q1, Q2, Q3: Si2300; SOT-23
R2, R3, R4: 470; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder

Connections:
+5V: J4.1, J4.3, J4.5; also elsewhere on the board
DIR1: Q2.1 (G); also elsewhere on the board
EN1: Q3.1 (G); also elsewhere on the board
GND: Q1.2 (S), Q2.2 (S), Q3.2 (S); also elsewhere on the board
unnamed: J4.2, R2.1
unnamed: J4.4, R3.1
unnamed: J4.6, R4.1
unnamed: Q1.3 (D), R2.2
unnamed: Q2.3 (D), R3.2
unnamed: Q3.3 (D), R4.2
STEP1: Q1.1 (G); also elsewhere on the board

Parts of its further copies:
J5, J6: Motor; PhoenixContact_MC_1,5_6-G-3.5_1x06_P3.50mm_Horizontal
Q4, Q5, Q6, Q7, Q8, Q9: Si2300; SOT-23
R5, R6, R7, R8, R9, R10: 470; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder

Connections of its further copies:
+5V: J5.1, J5.3, J5.5, J6.1, J6.3, J6.5; also elsewhere on the board
DIR2: Q5.1 (G); also elsewhere on the board
DIR3: Q8.1 (G); also elsewhere on the board
EN2: Q6.1 (G); also elsewhere on the board
EN3: Q9.1 (G); also elsewhere on the board
GND: Q4.2 (S), Q5.2 (S), Q6.2 (S), Q7.2 (S), Q8.2 (S), Q9.2 (S); also elsewhere on the board
unnamed: J5.2, R5.1
unnamed: J5.4, R6.1
unnamed: J5.6, R7.1
unnamed: J6.2, R8.1
unnamed: J6.4, R9.1
unnamed: J6.6, R10.1
unnamed: Q4.3 (D), R5.2
unnamed: Q5.3 (D), R6.2
unnamed: Q6.3 (D), R7.2
unnamed: Q7.3 (D), R8.2
unnamed: Q8.3 (D), R9.2
unnamed: Q9.3 (D), R10.2
STEP2: Q4.1 (G); also elsewhere on the board
STEP3: Q7.1 (G); also elsewhere on the board

Board: 2 copper layers, 47.0 x 71.6 mm, 48 parts (6 on the bottom side), 42 nets.

## Code that names these connections

File Hardware/LaserSwitch-Master/LaserSwitch-Master.ioc (part):

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PB13.GPIOParameters=GPIO_Label
PC7.GPIOParameters=GPIO_Label
Mcu.UserName=STM32F401RCTx
PB14.GPIO_Label=EN3
PH1\ -\ OSC_OUT.Mode=HSE-External-Oscillator
PC4.Signal=GPIO_Output
PC6.Signal=USART6_TX
PC6.GPIO_Label=BT_TX
PB0.GPIO_Label=EN1
PB13.GPIO_Label=DIR3
PB13.Signal=GPIO_Output
PB15.Signal=GPIO_Input
PA13.Signal=SYS_JTMS-SWDIO
PH0\ -\ OSC_IN.Mode=HSE-External-Oscillator
PH0\ -\ OSC_IN.Signal=RCC_OSC_IN
PB10.GPIO_Label=EN2
PC6.Mode=Asynchronous
PC5.GPIOParameters=GPIO_Label
PB2.GPIOParameters=GPIO_Label
PB6.Signal=I2C1_SCL
PC7.Signal=USART6_RX
PB6.Mode=I2C
PB10.Signal=GPIO_Output
PB14.Signal=GPIO_Output
RCC.HSE_VALUE=25000000
PH1\ -\ OSC_OUT.Signal=RCC_OSC_OUT
PB2.Signal=GPIO_Output
board=custom
PB12.GPIO_Label=STEP3
PB0.GPIOParameters=GPIO_Label
PC4.GPIO_Label=STEP1
PB15.GPIO_Label=CONN
PA14.Mode=Serial_Wire
PB1.GPIO_Label=STEP2
PB7.Signal=I2C1_SDA
PB15.GPIOParameters=GPIO_Label
PA13.Mode=Serial_Wire
Mcu.Name=STM32F401R(B-C)Tx
PC7.GPIO_Label=BT_RX
RCC.SYSCLKFreq_VALUE=16000000
Mcu.Package=LQFP64
PB1.Signal=GPIO_Output
PC5.GPIO_Label=DIR1
PB7.Mode=I2C
PA14.Signal=SYS_JTCK-SWCLK
PB2.GPIO_Label=DIR2
PC6.GPIOParameters=GPIO_Label
PB14.GPIOParameters=GPIO_Label
PC5.Signal=GPIO_Output
PB10.GPIOParameters=GPIO_Label
PC7.Mode=Asynchronous
PB0.Signal=GPIO_Output
PC4.GPIOParameters=GPIO_Label
PB12.GPIOParameters=GPIO_Label
PB12.Signal=GPIO_Output
PB1.GPIOParameters=GPIO_Label

File Hardware/LaserSwitch-Slave/LaserSwitch-Slave.ioc (part):

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PC7.GPIOParameters=GPIO_Label
PA10.Mode=Asynchronous
Mcu.UserName=STM32F401RCTx
PH1\ -\ OSC_OUT.Mode=HSE-External-Oscillator
PC2.Signal=GPIO_Input
PC6.Signal=USART6_TX
PC6.GPIO_Label=BT_TX
PC0.Signal=GPIO_Input
PB15.Signal=GPIO_Input
PA13.Signal=SYS_JTMS-SWDIO
PA9.Mode=Asynchronous
PH0\ -\ OSC_IN.Mode=HSE-External-Oscillator
PH0\ -\ OSC_IN.Signal=RCC_OSC_IN
PC6.Mode=Asynchronous
PA9.Signal=USART1_TX
PB6.Signal=I2C1_SCL
PC7.Signal=USART6_RX
PB6.Mode=I2C
PC3.Signal=GPIO_Input
RCC.HSE_VALUE=25000000
PH1\ -\ OSC_OUT.Signal=RCC_OSC_OUT
board=custom
PB15.GPIO_Label=CONN
PA14.Mode=Serial_Wire
PB7.Signal=I2C1_SDA
PB15.GPIOParameters=GPIO_Label
PA13.Mode=Serial_Wire
Mcu.Name=STM32F401R(B-C)Tx
PC7.GPIO_Label=BT_RX
RCC.SYSCLKFreq_VALUE=16000000
Mcu.Package=LQFP64
PB7.Mode=I2C
PA10.Signal=USART1_RX
PA14.Signal=SYS_JTCK-SWCLK
PC6.GPIOParameters=GPIO_Label
PC5.Signal=ADCx_IN15
PC7.Mode=Asynchronous
PC1.Signal=GPIO_Input
